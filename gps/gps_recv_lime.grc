options:
  parameters:
    author: biote
    generate_options: qt_gui
    id: gps_recv_lime
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4.096e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: gps_captured.iq
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: LNAW
    args: driver=lime,soapy=0
    bb_gain0: '19'
    dc_offset_mode0: '2'
    freq0: 1575.42e6
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '12'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
