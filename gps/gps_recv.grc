options:
  parameters:
    author: biote
    generate_options: qt_gui
    id: gps_recv
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4.096e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: Microsoft.PowerShell.Core\FileSystem::\\wsl.localhost\Ubuntu\tmp\gps_iq
    type: complex
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '5555'
    type: complex
  states: {state: disabled}
- name: network_tcp_sink_1
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '5555'
    type: complex
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '40'
    clock_source0: gpsdo
    freq0: 1575.42e6
    gain0: '25'
    gain_mode0: 'False'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}

connections:
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', network_tcp_sink_0, '0']
- [osmosdr_source_0, '0', network_tcp_sink_1, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
